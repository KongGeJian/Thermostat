# Keil uVision project Thermostat.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Thermostat
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\DevTool\Keil_v5\C51\INC\**;.\src\APP;.\src\BSP;.\src\EXT-LIB;.\src\OS
  link misc: REMOVEUNUSED
  group APP
    ./src/APP/: app.c app.h cfg.h STARTUP.A51
  group BSP
    ./src/BSP/: bsp.c bsp.h bsp_buzzer.c bsp_buzzer.h bsp_eeprom.c bsp_eeprom.h bsp_kbd.c bsp_kbd.h bsp_seg.c bsp_seg.h bsp_uart.c bsp_uart.h bsp_ntc.c bsp_ntc.h bsp_relay.c bsp_relay.h
  group EXT-LIB
    ./src/EXT-LIB/: lib_delay.c lib_delay.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_stdint.h lib_str.c lib_str.h
  group OS
    ./src/OS/: os.c os.h os_timer.c os_timer.h
